# IAR project RT_17011_CCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\SourceRespo\ChibiOS\chibios203\os\common\abstractions\cmsis_os; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ARM\CMSIS\Core\Include; D:\SourceRespo\ChibiOS\chibios203\os\common\ext\ST\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx\compilers\IAR; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\oslib\include; D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\hal\include; D:\SourceRespo\ChibiOS\chibios203\os\hal\lib\streams; D:\SourceRespo\ChibiOS\chibios203\os\hal\osal\rt-nil; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\common\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\ADCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\CANv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\DMAv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\EXTIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\GPIOv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\I2Cv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\MACv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\OTGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\QUADSPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\RTCv2; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SDIOv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\SPIv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\TIMv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\USARTv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\LLD\xWDGv1; D:\SourceRespo\ChibiOS\chibios203\os\hal\ports\STM32\STM32F4xx; D:\SourceRespo\ChibiOS\chibios203\os\rt\include; D:\SourceRespo\ChibiOS\chibios203\os\various\shell; D:\SourceRespo\ChibiOS\chibios203\os\various\fatfs_bindings; cfg; Board; src; D:\SourceRespo\ylib\adda\ads1x15; D:\SourceRespo\ylib\eeprom
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\SourceRespo\ChibiOS\chibios203\os\license; D:\SourceRespo\ChibiOS\chibios203\os\common\ports\ARMCMx; D:\SourceRespo\ChibiOS\chibios203\os\common\startup\ARMCMx\devices\STM32F4xx; cfg; Board; src
  ILINK.IlinkOutputFile: RT_17011_CCU.out
  ILINK.IlinkIcfFile: ch_stm32f407.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Board
    Board/: board.c board.h
  group cfg
    cfg/: chconf.h halconf.h mcuconf.h
  group chibi_203/common/abstractions/cmsis_os
    $extsource$/ChibiOS/chibios203/os/common/abstractions/cmsis_os/: cmsis_os.c cmsis_os.h
  group chibi_203/common/abstractions/nasa_cfe/osal
    $extsource$/ChibiOS/chibios203/os/common/abstractions/nasa_cfe/osal/src/: osapi.c
  group chibi_203/common/abstractions/nasa_cfe/psp
    $extsource$/ChibiOS/chibios203/os/common/abstractions/nasa_cfe/psp/src/: cfe_psp_exception.c cfe_psp_memory.c cfe_psp_support.c cfe_psp_timer.c
  group chibi_203/common/ports
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/: chcore.c chcore_v6m.c chcore_v7m.c
    $extsource$/ChibiOS/chibios203/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v6m.s chcoreasm_v7m.s
  group chibi_203/common/startup
    $extsource$/ChibiOS/chibios203/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group chibi_203/hal/lib/complex/mfs
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/mfs/: hal_mfs.c
  group chibi_203/hal/lib/complex/serial_nor
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/devices/macronix_mx25/: hal_flash_device.c
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/devices/micron_n25q/: hal_flash_device.c
    $extsource$/ChibiOS/chibios203/os/hal/lib/complex/serial_nor/: hal_serial_nor.c
  group chibi_203/hal/lib/streams
    $extsource$/ChibiOS/chibios203/os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group chibi_203/hal/osal/lib
    $extsource$/ChibiOS/chibios203/os/hal/osal/lib/: osal_vt.c
  group chibi_203/hal/osal/os-less
    $extsource$/ChibiOS/chibios203/os/hal/osal/os-less/ARMCMx/: osal.c
  group chibi_203/hal/osal/rt-nil
    $extsource$/ChibiOS/chibios203/os/hal/osal/rt-nil/: osal.c
  group chibi_203/hal/ports/common
    $extsource$/ChibiOS/chibios203/os/hal/ports/common/ARMCMx/: nvic.c
  group chibi_203/hal/ports/STM32/LLD/ADCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv1/: hal_adc_lld.c
  group chibi_203/hal/ports/STM32/LLD/ADCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv2/: hal_adc_lld.c
  group chibi_203/hal/ports/STM32/LLD/ADCv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv3/: hal_adc_lld.c
  group chibi_203/hal/ports/STM32/LLD/ADCv4
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/ADCv4/: hal_adc_lld.c
  group chibi_203/hal/ports/STM32/LLD/BDMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/BDMAv1/: stm32_bdma.c
  group chibi_203/hal/ports/STM32/LLD/CANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
  group chibi_203/hal/ports/STM32/LLD/CRYPv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/CRYPv1/: hal_crypto_lld.c
  group chibi_203/hal/ports/STM32/LLD/DACv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
  group chibi_203/hal/ports/STM32/LLD/DMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DMAv1/: stm32_dma.c
  group chibi_203/hal/ports/STM32/LLD/DMAv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/DMAv2/: stm32_dma.c
  group chibi_203/hal/ports/STM32/LLD/EXTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c
  group chibi_203/hal/ports/STM32/LLD/FDCANv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/FDCANv1/: hal_can_lld.c
  group chibi_203/hal/ports/STM32/LLD/GPIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv1/: hal_pal_lld.c
  group chibi_203/hal/ports/STM32/LLD/GPIOv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
  group chibi_203/hal/ports/STM32/LLD/GPIOv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/GPIOv3/: hal_pal_lld.c
  group chibi_203/hal/ports/STM32/LLD/I2Cv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv1/: hal_i2c_lld.c
  group chibi_203/hal/ports/STM32/LLD/I2Cv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv2/: hal_i2c_lld.c
  group chibi_203/hal/ports/STM32/LLD/I2Cv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/I2Cv3/: hal_i2c_lld.c
  group chibi_203/hal/ports/STM32/LLD/MACv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/MACv1/: hal_mac_lld.c
  group chibi_203/hal/ports/STM32/LLD/MDMAv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/MDMAv1/: stm32_mdma.c
  group chibi_203/hal/ports/STM32/LLD/OCTOSPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/OCTOSPIv1/: hal_wspi_lld.c
  group chibi_203/hal/ports/STM32/LLD/OTGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/OTGv1/: hal_usb_lld.c
  group chibi_203/hal/ports/STM32/LLD/QUADSPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/QUADSPIv1/: hal_wspi_lld.c
  group chibi_203/hal/ports/STM32/LLD/QUADSPIv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/QUADSPIv2/: hal_wspi_lld.c
  group chibi_203/hal/ports/STM32/LLD/RNGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RNGv1/: hal_trng_lld.c
  group chibi_203/hal/ports/STM32/LLD/RTCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv1/: hal_rtc_lld.c
  group chibi_203/hal/ports/STM32/LLD/RTCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
  group chibi_203/hal/ports/STM32/LLD/RTCv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/RTCv3/: hal_rtc_lld.c
  group chibi_203/hal/ports/STM32/LLD/SDIOv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDIOv1/: hal_sdc_lld.c
  group chibi_203/hal/ports/STM32/LLD/SDMMCv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDMMCv1/: hal_sdc_lld.c
  group chibi_203/hal/ports/STM32/LLD/SDMMCv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SDMMCv2/: hal_sdc_lld.c
  group chibi_203/hal/ports/STM32/LLD/SPIv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv1/: hal_i2s_lld.c hal_spi_lld.c
  group chibi_203/hal/ports/STM32/LLD/SPIv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv2/: hal_i2s_lld.c hal_spi_lld.c
  group chibi_203/hal/ports/STM32/LLD/SPIv3
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/SPIv3/: hal_i2s_lld.c hal_spi_lld.c
  group chibi_203/hal/ports/STM32/LLD/TIMv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c
  group chibi_203/hal/ports/STM32/LLD/USARTv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USARTv1/: hal_serial_lld.c hal_uart_lld.c
  group chibi_203/hal/ports/STM32/LLD/USARTv2
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USARTv2/: hal_serial_lld.c hal_uart_lld.c
  group chibi_203/hal/ports/STM32/LLD/USBv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
  group chibi_203/hal/ports/STM32/LLD/xWDGv1
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c
  group chibi_203/hal/ports/STM32/STM32F1xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32F1xx/: hal_adc_lld.c hal_efl_lld.c hal_lld_lld.c
  group chibi_203/hal/ports/STM32/STM32F4xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32F4xx/: hal_efl_lld.c hal_lld.c stm32_isr.c
  group chibi_203/hal/ports/STM32/STM32L1xx
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32L1xx/: hal_adc_lld.c hal_lld_lld.c stm32_isr.c
  group chibi_203/hal/ports/STM32/STM32L4xx+
    $extsource$/ChibiOS/chibios203/os/hal/ports/STM32/STM32L4xx+/: hal_efl_lld.c hal_lld_lld.c stm32_isr.c
  group chibi_203/hal/src
    $extsource$/ChibiOS/chibios203/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group chibi_203/nil
    $extsource$/ChibiOS/chibios203/os/nil/src/: ch.c chevt.c chmsg.c chsem.c
  group chibi_203/oslib
    $extsource$/ChibiOS/chibios203/os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group chibi_203/rt
    $extsource$/ChibiOS/chibios203/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group chibi_203/various
    $extsource$/ChibiOS/chibios203/os/various/: evtimer.c syscalls.c
  group chibi_203/various/cpp_wrappers
    $extsource$/ChibiOS/chibios203/os/various/cpp_wrappers/: ch.cpp ch.hpp syscalls_cpp.cpp syscalls_cpp.hpp
  group chibi_203/various/fatfs_bindings
    $extsource$/ChibiOS/chibios203/os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
  group chibi_203/various/lwip_bindings
    $extsource$/ChibiOS/chibios203/os/various/lwip_bindings/: lwipthread.c
    $extsource$/ChibiOS/chibios203/os/various/lwip_bindings/arch/: sys_arch.c
  group chibi_203/various/shell
    $extsource$/ChibiOS/chibios203/os/various/shell/: shell.c shell_cmd.c
  group chibi_203/various/wolfssl_bindings
    $extsource$/ChibiOS/chibios203/os/various/wolfssl_bindings/: hwrng.c wolfssl_chibios.c
  group Src
    src/: gpio_drv.c peripheral_if.c sysParam.c
  group Src/CCU
    src/: app_ccu.c main.c
  group YLIB
    $extsource$/ylib/adda/ads1x15/: ads1015.c
    $extsource$/ylib/eeprom/: at24_eep.c
